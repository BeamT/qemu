## tests/esp_wifi/apps/espnow_ack/main/Kconfig.projbuild
```kconfig
menu "ESP-NOW test"
    config ESPNOW_TEST_ENCRYPT
        bool "Encrypt unicast frames to the peer"
        default n
endmenu
```
